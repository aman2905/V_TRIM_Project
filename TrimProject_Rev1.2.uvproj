# Keil uVision project TrimProject_Rev1.2.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: TrimProject_Rev1.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include
  group Source Group 1
    ./: STARTUP.A51 main.c main.h
  group Include
    ./Include/: Common.h Delay.h Function_Define.h N76E003.h SFR_Macro.h
